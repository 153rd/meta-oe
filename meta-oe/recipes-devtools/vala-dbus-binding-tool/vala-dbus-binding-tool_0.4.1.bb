require vala-dbus-binding-tool.inc

SRC_URI[archive.md5sum] = "76540eb575bef04d4250166208c0bb5b"
SRC_URI[archive.sha256sum] = "656e8fedaac7ab783bbe4bcfb3584c785998792136d8e3fd83e4956613a6e728"
